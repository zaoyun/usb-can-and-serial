# Repository zaoyun/usb-can-and-serial

## KiCad design usb-can and serial.kicad_pcb

Parts:
C1, C2: 12pf; C_0402_1005Metric
C3, C4: 10uf; C_0402_1005Metric
C5, C6: 12pF; C_0402_1005Metric
C7, C8, C10, C12, C17, C20, C21: 0.1uF; C_0402_1005Metric
C9, C13, C15, C16, C22, C23, C24, C25, C26, C27, C28, C29: 1uF; C_0402_1005Metric
C11, C14, C18, C19: 1uf; C_0402_1005Metric
D1: LED_R; D_0402_1005Metric
D2, D10, D12, D14: LED_B; D_0402_1005Metric
D3: LED; LED_0402_1005Metric
D4, D5, D8: PSD05C; D_SOD-323
D9, D11, D13: LED_G; D_0402_1005Metric
F1, F2, F3, F4, F5: Fuse; Fuse_0603_1608Metric
F6, F7, F8, F9: 0.5A; Fuse_0603_1608Metric
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
J2, J3, J4: CAN; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
J6: Conn_01x03_Male; JST_GH_SM03B-GHS-TB_1x03-1MP_P1.25mm_Horizontal
J7: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J8, J9, J10, J11: Conn_01x04_Male; PinHeader_1x04_P1.27mm_Vertical
Q1: MMBT3904T; SOT-523
R1, R2, R5, R6, R13, R14, R18, R19, R20, R21: 510R; R_0402_1005Metric
R3: 2.7k; R_0402_1005Metric
R4, R12: 1.5K; R_0402_1005Metric
R7, R8, R15, R16, R22, R23, R24, R25: 20K; R_0402_1005Metric
R9, R11, R17, R26, R27: 10K; R_0402_1005Metric
R10: 1K; R_0402_1005Metric
R28, R29, R30: 120R; R_0402_1005Metric
R31, R32: 22R; R_0402_1005Metric
U1: FE8.1; SSOP-16_4.4x5.2mm_P0.65mm
U2: STM32F103C8T6; LQFP-48_7x7mm_P0.5mm
U3, U4, U6: STM32F072C8T6; LQFP-48_7x7mm_P0.5mm
U5, U7, U8: MAX3051; SOT-23-8
U9, U10, U11, U12: XC6206P332MR; SOT-23
Y1: 12MHZ; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm
Y2: Crystal_8M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C3.1, R4.1, U1.13 (VD33F)
+5V: C4.1, C11.2, C14.2, C18.2, C19.2, F1.2, F2.2, F3.2, F4.2, F5.2, F6.2, F7.2, F8.2, F9.2, J7.2, R6.2, U1.12 (VDD5)
/3.3V_1: C7.1, C23.1, R1.1, R2.1, R7.1, R9.1, R11.2, R12.2, U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U9.2 (VO)
/3.3V_2: C12.1, C17.1, C29.1, R13.1, R14.1, R15.1, R17.1, U4.1 (VBAT), U4.9 (VDDA), U4.24 (VDD), U4.36 (VDDIO2), U4.48 (VDD), U5.3 (VDD), U12.2 (VO)
/3.3V_3: C10.1, C21.1, C28.1, R20.1, R21.1, R24.1, R27.1, U6.1 (VBAT), U6.9 (VDDA), U6.24 (VDD), U6.36 (VDDIO2), U6.48 (VDD), U8.3 (VDD), U11.2 (VO)
/3.3V_4: C8.1, C20.1, C27.1, R18.1, R19.1, R22.1, R26.1, U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDDIO2), U3.48 (VDD), U7.3 (VDD), U10.2 (VO)
/BOOT0_1: R7.2, R8.1, U2.44 (BOOT0)
/BOOT0_2: R15.2, R16.1, U4.44 (BOOT0)
/BOOT0_3: R24.2, R25.1, U6.44 (BOOT0)
/BOOT0_4: R22.2, R23.1, U3.44 (BOOT0)
/CAN1+: J2.2, R29.1, U5.7 (CANH)
/CAN1-: J2.1, R29.2, U5.6 (CANL)
/CAN1_RX: U4.45 (PB8), U5.4 (RXD)
/CAN1_TX: U4.46 (PB9), U5.1 (TXD)
/CAN2+: J3.2, R30.1, U8.7 (CANH)
/CAN2-: J3.1, R30.2, U8.6 (CANL)
/CAN2_RX: U6.45 (PB8), U8.4 (RXD)
/CAN2_TX: U6.46 (PB9), U8.1 (TXD)
/CAN3+: J4.2, R28.1, U7.7 (CANH)
/CAN3-: J4.1, R28.2, U7.6 (CANL)
/CAN3_RX: U3.45 (PB8), U7.4 (RXD)
/CAN3_TX: U3.46 (PB9), U7.1 (TXD)
/DBUS1_RX: J7.1, R10.1
/DBUS_RX: D8.1 (K)
/LED1: D2.1 (K), U2.2 (PC13)
/LEDRX_1: D9.1 (K), U4.18 (PB0)
/LEDRX_2: D13.1 (K), U6.18 (PB0)
/LEDRX_3: D11.1 (K), U3.18 (PB0)
/LEDTX_1: D10.1 (K), U4.19 (PB1)
/LEDTX_2: D14.1 (K), U6.19 (PB1)
/LEDTX_3: D12.1 (K), U3.19 (PB1)
/NRST1: C9.1, R9.2, U2.7 (NRST)
/NRST2: C13.1, R17.2, U4.7 (NRST)
/NRST3: C16.1, R27.2, U6.7 (NRST)
/NRST4: C15.1, R26.2, U3.7 (NRST)
/OSC_IN: C5.2, U2.5 (PD0), Y2.3
/OSC_OUT: C6.2, U2.6 (PD1), Y2.1
/UART1_RX: D5.1 (K), J6.2, U2.22 (PB11)
/UART1_TX: D4.1 (K), J6.3, U2.21 (PB10)
/UART2_RX: Q1.3 (C), R11.1, U2.13 (PA3)
/USB1+: R31.1, U1.8 (DM1+), U2.33 (PA12)
/USB1-: R32.1, U1.7 (DM1-), U2.32 (PA11)
/USB2+: J10.3, U1.6 (DM2+), U4.33 (PA12)
/USB2-: J10.2, U1.5 (DM2-), U4.32 (PA11)
/USB3+: J11.3, U1.4 (DM3+), U6.33 (PA12)
/USB3-: J11.2, U1.3 (DM3-), U6.32 (PA11)
/USB4+: J9.3, U1.2 (DM4+), U3.33 (PA12)
/USB4-: J9.2, U1.1 (DM4-), U3.32 (PA11)
/USB+: J1.A6 (D+), J1.B6 (D+), R4.2, U1.11 (DPU+)
/USB-: J1.A7 (D-), J1.B7 (D-), U1.10 (DMU-)
GND: C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, C18.1, C19.1, C20.2, C21.2, C22.1, C23.2, C24.1, C25.1, C26.1, C27.2, C28.2, C29.2, D1.1 (K), D3.1 (K), D4.2 (A), D5.2 (A), D8.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J6.1, J7.3, J8.4, J9.4, J10.4, J11.4, Q1.2 (E), R3.2, R5.2, R8.2, R16.2, R23.2, R25.2, U1.14 (VSS), U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.8 (VSSA), U4.23 (VSS), U4.35 (VSS), U4.47 (VSS), U5.2 (GND), U5.5 (SHDN), U5.8 (RS), U6.8 (VSSA), U6.23 (VSS), U6.35 (VSS), U6.47 (VSS), U7.2 (GND), U7.5 (SHDN), U7.8 (RS), U8.2 (GND), U8.5 (SHDN), U8.8 (RS), U9.1 (GND), U10.1 (GND), U11.1 (GND), U12.1 (GND)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
unnamed: C1.1, U1.16 (XOUT)
unnamed: C1.2, Y1.1
unnamed: C2.1, U1.15 (XIN)
unnamed: C2.2, Y1.3
unnamed: C22.2, F6.1, U9.3 (VI)
unnamed: C24.2, F7.1, U10.3 (VI)
unnamed: C25.2, F8.1, U11.3 (VI)
unnamed: C26.2, F9.1, U12.3 (VI)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R6.1
unnamed: D9.2 (A), R13.2
unnamed: D10.2 (A), R14.2
unnamed: D11.2 (A), R18.2
unnamed: D12.2 (A), R19.2
unnamed: D13.2 (A), R20.2
unnamed: D14.2 (A), R21.2
unnamed: F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: F2.1, J9.1
unnamed: F3.1, J8.1
unnamed: F4.1, J10.1
unnamed: F5.1, J11.1
unnamed: J1.A5 (CC1), J1.B5 (CC2), R5.1
unnamed: J8.2, R32.2
unnamed: J8.3, R12.1, R31.2
unnamed: Q1.1 (B), R10.2
unnamed: R3.1, U1.9 (REXT)

Notes on the sheet:
CAN3
LED
主控芯片
RST&BOOT
CAN
DBUS
type-c输入
USB
LDO
SERIAL
OSC
CAN
CAN2
驱动引脚
MCU
CONN
CAN1
Serial
USB2.0 HUB

Board: 2 copper layers, 36.2 x 39.8 mm, 107 parts (52 on the bottom side), 77 nets.
